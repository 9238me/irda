# Keil uVision project 23_disp_irda.uvprojx, settings and files
target 23_disp_irda (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: 23_disp_irda +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../1_Applications;../2_Deivces;../3_ModuleDrivers;../4_Includes;../5_Libs
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c i2c.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group 1_Applications
    ../1_Applications/: app_irda_test.c
  group 2_Devices
    ../2_Deivces/: devices.h dev_gpio.c dev_spi.c dev_uart.c dev_i2c.c dev_timer.c
  group 2_Device/Modules
    ../2_Deivces/w25q/: dev_w25q64.c
    ../2_Deivces/display/: dev_st7789v.c
    ../2_Deivces/at24c/: dev_at24c02.c
    ../2_Deivces/motor/: dev_motor.c
    ../2_Deivces/servo/: dev_servo.c
    ../2_Deivces/irda/: dev_irda.c
  group 3_ModuleDrivers
    ../3_ModuleDrivers/: drivers.h drv_gpio.c drv_spi.c drv_uart.c drv_i2c.c drv_timer.c drv_pwm.c
    ../3_ModuleDrivers/drv_config/: gpio_config.h spi_config.h uart_config.h timer_config.h pwm_config.h
  group 4_Include
    ../4_Includes/: config.h errno.h mytype.h
  group 5_Libs
    ../5_Libs/: libs.h
    ../5_Libs/printf/: printf.c
    ../5_Libs/ring_buffer/: ring_buffer.c
    ../5_Libs/delay/: delay.c
    ../5_Libs/font/: ascii.c font.c
software components: CMSIS:CORE 4.3.0
